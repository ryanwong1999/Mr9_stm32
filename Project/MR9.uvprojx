# Keil uVision project MR9.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MR9 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c include: ..\CORE;..\FWLIB\inc;..\Source\App\inc;..\Source\Bsp\inc;..\Source\SYSTEM;..\Source\User;..\UCOSIII\uCOSIII_Core;..\UCOSIII\uCOSIII_Ports;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uC_CPU;..\UCOSIII\uC_LIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dma2d.c stm32f4xx_syscfg.c
  group UCOSIII_CPU
    ../UCOSIII/uC_CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC_LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: os_app_hooks.c
  group UCOSIII_PORTS
    ../UCOSIII/uCOSIII_Ports/: os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOSIII_Core/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group BSP
    ../Source/Bsp/src/: Bsp_ADC_Cfg.c Bsp_CAP_Cfg.c Bsp_GPIO_Cfg.c Bsp_IIC.c Bsp_PWM_Cfg.c Bsp_RS485_Cfg.c Bsp_TIM_Cfg.c Bsp_USART_Cfg.c inet.c Bst_iwdg.c
  group APP
    ../Source/App/src/: App_24cxx.c App_AutoCharge.c App_AnalysisCMD.c App_Cap.c App_Environmental.c App_Exti.c App_Head_Done.c App_LiftMoto.c App_MotoDrv.c App_PID.c App_Pms.c App_System.c App_Task.c App_Test.c App_TIM.c App_Ultrasonic.c App_USART.c
  group SYSTEM
    ../Source/SYSTEM/: delay.c dma.c malloc.c sys.c usart.c
  group USER
    ../Source/User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group README
    ../: README.md
